# Keil uVision project Project.uvprojx, settings and files
target SY-STM32F407 V2.0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  BeforeMake: python.exe ../../toolchain/updateIP.py
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,USE_SEER_ASSERT
  c misc: --cpp --cpp11
  c include: ..\..\Libraries\FWlib\inc;..\Startup;..\User;..\wiznet;..\iap;..\..\Libraries\CMSIS\inc;..\..\logger;..\..\HAL;..\..\utility;..\..\NetworkAdapter;..\..\socket;..\..\w5500socket;..\..\protobuffer;.\opts
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c main.cpp udpDevice.cpp HeartLed.c powerupDefaultValue.cpp
  group FWlib
    ../../Libraries/FWlib/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_can.c stm32f4xx_iwdg.c
  group CMSIS
    ../../Libraries/CMSIS/src/: system_stm32f4xx.c
  group Startup
    ../Startup/: startup_stm32f4xx.s
  group Doc
    ../../iapTools/: iapBlFlasher.py
  group IAP
    ../iap/: iap.c st_bootloader_protocol.c
  group logger
    ../../logger/: CCanConsole.cpp Console.cpp CUartConsole.cpp CUdpConsole.cpp SEGGER_RTT.c
  group wiznet
    ../../w5500socket/src/: lstring.c socket.c w5500.c wizchip_conf.c w5500_retarget.cpp W5500Device.cpp
  group HAL
    ../../HAL/: CommonConfig.c CCan.cpp CUsart.cpp Timer.cpp watchDog.cpp CSpi.cpp stmflash.c powerupOption.cpp
  group NetworkAdapter
    ../../NetworkAdapter/W5500/: NetworkAdapter.cpp
  group socket
    ../../socket/: byteston.c
    ../../socket/w5500/: socket.cpp
software components: CMSIS:CORE 4.3.0
