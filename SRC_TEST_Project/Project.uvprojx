# Keil uVision project Project.uvprojx, settings and files
target SY-STM32F407 V2.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.sc2.bin" "#L"
  AfterMake: python.exe ../toolchain/renameApp.py
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_USED,__FPU_PRESENT,RUN_FOR_SRC_2000
  c misc: --cpp --cpp11
  c include: ..\src\Libraries\CMSIS\inc;..\src\Libraries\FWlib\inc;..\src\User;..\src;..\src\socket;..\RTT;..\src\polarSSL\include;..\src\modbus;..\src\HAL;..\src\logger;.\ErrorCode;..\src\utility;..\src\math;..\src\NetworkAdapter;..\src\LWIP;..\src\LWIP\arch;..\src\LWIP\lwip_header;..\src\LWIP\app\TCP_Client;..\src\LWIP\lwip_app\lwip_comm;..\src\LWIP\lwip-1.4.1\src\include;..\src\LWIP\lwip-1.4.1\src\include\ipv4;..\src\LWIP\lwip-1.4.1\src\include\lwip;..\src\LWIP\lwip-1.4.1\src\include\netif;..\src\LWIP\lwip_app\lwip_comm;.\opts;..\src\lan8720;..\src\Core;..\src\Libraries\STM32F4x7_ETH_Driver\inc;..\src\GPIO-DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xd0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/User/: stm32f4xx_it.c main.cpp ipconfig.json
  group FWlib
    ../src/Libraries/FWlib/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_can.c stm32f4xx_iwdg.c stm32f4xx_flash.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_i2c.c
    ../src/Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group CMSIS
    ../src/User/: powerupDefaultValue.cpp
    ../src/Libraries/CMSIS/src/: system_stm32f4xx.c
  group Startup
    ../src/Startup/: startup_stm32f4xx.s
  group src
    ../src/Core/: TaskManager.cpp GlobalData.cpp Utils.cpp CanRouterTask.cpp Reporter.cpp CommandDispatchTask.cpp Replier.cpp ControllerSurveyorTask.cpp
  group socket
    ../src/socket/: byteston.c
    ../src/socket/LAN8720/: socket.cpp
  group HAL
    ../src/HAL/: CommonConfig.c CCan.cpp CUsart.cpp Timer.cpp stmflash.c powerupOption.cpp
  group logger
    ../src/logger/: rtt_vsnprintf.c SEGGER_RTT.c Console.cpp CUartConsole.cpp CUdpConsole.cpp CCanConsole.cpp
  group math
    ../src/math/: Matrix.cpp nanoNewMat.cpp
    ../src/Libraries/CMSIS/DSP/MatrixFunctions/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
  group lwip-netif
    ../src/LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group lwip-core
    ../src/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../src/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c mem.c
  group lwip-arch
    ../src/LWIP/arch/: sys_arch.c
  group lwip-api
    ../src/LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group NetworkAdapter
    ../src/NetworkAdapter/LAN8720/: NetworkAdapter.cpp
  group lwip-common
    ../src/LWIP/lwip_app/lwip_comm/: lwip_comm.c
  group lan8720
    ../src/lan8720/: lan8720.c sys.c
  group dio
    ../src/GPIO-DRIVER/: DIO_TEST.cpp
software components: CMSIS:CORE 5.0.1
