# Keil uVision project Project.uvprojx, settings and files
target SY-STM32F407 V2.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  BeforeMake: python.exe ../../toolchain/updateIP.py
  AfterMake: fromelf.exe --bin -o "$L@L.sc2b.bin" "#L"
  AfterMake: python.exe ../../toolchain/renameBL.py
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,USE_SEER_ASSERT,RUN_FOR_SRC_2000
  c misc: --cpp --cpp11
  c include: ..\..\src\Libraries\FWlib\inc;..\Startup;..\User;..\wiznet;..\iap;..\..\src\Libraries\CMSIS\inc;..\..\src\logger;..\..\src\HAL;..\..\src\utility;..\..\src\NetworkAdapter;..\..\src\socket;..\..\src\protobuffer;..\..\src\LWIP;..\..\src\LWIP\arch;..\..\src\LWIP\lwip_header;..\..\src\LWIP\app\TCP_Client;..\..\src\LWIP\lwip_app\lwip_comm;..\..\src\LWIP\lwip-1.4.1\src\include;..\..\src\LWIP\lwip-1.4.1\src\include\ipv4;..\..\src\LWIP\lwip-1.4.1\src\include\lwip;..\..\src\LWIP\lwip-1.4.1\src\include\netif;..\..\src\Libraries\STM32F4x7_ETH_Driver\inc;..\..\src\LWIP\lwip_app\lwip_comm;.\opts;..\..\src\lan8720;..\GPIO-DRIVER;..\..\src\GPIO-DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c main.cpp udpDevice.cpp HeartLed.c powerupDefaultValue.cpp
  group FWlib
    ../../src/Libraries/FWlib/src/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_can.c stm32f4xx_iwdg.c stm32f4xx_syscfg.c
    ../../src/Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group CMSIS
    ../../src/Libraries/CMSIS/src/: system_stm32f4xx.c
  group Startup
    ../Startup/: startup_stm32f4xx.s
  group Doc
    ../../iapTools/: iapBlFlasher.py
  group IAP
    ../iap/: iap.c st_bootloader_protocol.c
  group logger
    ../../src/logger/: Console.cpp CUdpConsole.cpp SEGGER_RTT.c
  group HAL
    ../../src/HAL/: CommonConfig.c Timer.cpp stmflash.c powerupOption.cpp
  group NetworkAdapter
    ../../src/NetworkAdapter/LAN8720/: NetworkAdapter.cpp
  group socket
    ../../src/socket/: byteston.c
    ../../src/socket/LAN8720/: socket.cpp
  group lwip-common
    ../../src/LWIP/lwip_app/lwip_comm/: lwip_comm.c
  group lwip-netif
    ../../src/LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group lwip-core
    ../../src/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../src/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c mem.c
  group lwip-arch
    ../../src/LWIP/arch/: sys_arch.c
  group lwip-api
    ../../src/LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lan8720
    ../../src/lan8720/: lan8720.c sys.c
  group DIO
    ../../src/GPIO-DRIVER/: DIO_TEST.cpp
software components: CMSIS:CORE 5.0.1
